# Repository andreapiccini/spaghettilab-community (continued)

## KiCad design hardware/backbone-square16/backbone.kicad_pcb

File hardware/backbone-square16/README.md:

# Backbone a 16 righe — variante separata

Stato: assegnazione GPIO e circuito a 16 porte applicati e verificati sulla netlist. PCB sincronizzato, disposizione preliminare 68 × 68 mm, non sbrogliato e non pronto per produzione. La Backbone originale non è stata sovrascritta.

Aprire `backbone.kicad_pro`. Il secondo foglio `ports16.kicad_sch` contiene i dieci canali aggiunti e i nuovi comandi. `gpio16-allocation.csv` è la tabella completa; `connectivity-checks.json` riporta le verifiche di collegamento.

## Righe configurabili

| Posizione | Sinistra: GPIO | Destra: GPIO |
|---|---:|---:|
| 1 | 7 | 12 |
| 2 | 8 | 15 |
| 3 | 9 | 16 |
| 4 | 10 | 38 |
| 5 | 1 | 39 |
| 6 | 2 | 40 |
| 7 | 6 | 41 |
| 8 | 11 | 42 |

Sinistra: J18/J19/J21, contatti 1–8, reti PORT_A0–PORT_A7. Destra: J22/J23/J24, contatti 1–8, reti PORT_A8–PORT_A15. Ogni riga ha tre contatti comuni. Le due metà sono indipendenti: nessuna matrice di collegamento fra righe.

Ogni riga dispone di selezione VCORE (3,3 V), GND, GPIO o alta impedenza mediante MOSFET e switch analogico. I GPIO non sono tolleranti a 5 V. Le nuove porte riprendono la topologia delle sei esistenti: shunt 0,1 Ω con prese Kelvin e collegamento 0 Ω rimovibile verso lo stadio di potenza. Il valore dello shunt non costituisce una specifica di corrente o di accuratezza già validata per la futura mezzanina.

L1–L7 hanno ADC1; L8 e R1–R3 hanno ADC2, con le limitazioni del relativo driver/modalità di acquisizione. R4–R8 non hanno ADC diretto. Tutti i 16 segnali restano GPIO reali del micro; gli expander comandano solo le selezioni e i servizi lenti.

## Funzioni conservate

| Funzione | GPIO conservati |
|---|---|
| I²C | 4, 5 |
| CAN | 17, 18 |
| USB | 19, 20 |
| LED RGB | 21 |
| Collegamento SPI e relativi segnali di controllo | 13, 14, 43, 44 |
| UART di programmazione AG32 | 47, 48 |

I GPIO 0, 3, 45 e 46 non sono assegnati alle righe; GPIO35–37 sono esclusi perché riservati alla PSRAM della variante ESP32 prevista. Gli eventuali collegamenti storici di questi segnali sulla vecchia interfaccia mezzanina non li rendono disponibili: andranno trattati come riservati nella revisione del connettore.

Le reti preesistenti dei servizi arrivano ancora ai rispettivi connettori. I comandi prima attestati ai dieci GPIO recuperati ora fanno capo agli expander. Il vecchio firmware non è compatibile con questa variante senza aggiornamento.

## Comandi aggiunti

Tre TCA9535 della famiglia già usata, U32/U33/U34, indirizzi I²C a 7 bit 0x21/0x22/0x23. U25 resta a 0x20. Gli indirizzi 0x20–0x23 devono essere riservati sulla rete I²C condivisa.

- U32: comandi P/N delle porte A6–A13, alternati su P00…P07 e P10…P17.
- U33: P/N delle porte A14–A15, dieci enable degli switch A6–A15 e ESP_ISO4_N/ESP_ISO5_N.
- U34: P00=MEAS_S0, P01=MEAS_S1, P02=MEAS_S2, P03=MEAS_INHIBIT, P04=EXT_SPI_CS_N, P05=ESP_AG_BOOT0, P06=ESP_AG_RESET_N, P07=MEZZ_PRESENT_N (ingresso). P10–P17 sono collegati a GND e devono restare ingressi.

La selezione EXT_SPI_CS_N ora richiede una transazione I²C: utilizzarla ai confini di una transazione SPI, mantenendola attiva durante il trasferimento. Non è più un chip-select commutabile direttamente a ogni parola tramite periferica ESP. Clock e dati del collegamento SPI conservano i GPIO diretti. Boot/reset dell'AG32 restano disponibili con il nuovo comando I²C.

## Contratto firmware da implementare

Gli expander partono come ingressi a freddo. Pull-up dei gate P e degli enable, e pull-down dei gate N, tengono disattivati i dieci nuovi stadi. Il reset del solo ESP32 non resetta gli expander: non garantisce il ritorno automatico in alta impedenza. Le sei porte esistenti conservano anche la loro logica di ownership.

Prima di rendere gli expander uscite, scrivere i latch nello stato sicuro. Per i nuovi componenti:

| Expander | Output port 0 | Output port 1 | Configuration port 0 | Configuration port 1 |
|---|---|---|---|---|
| U32 | 0x55 | 0x55 | 0x00 | 0x00 |
| U33 | 0xF5 | 0xFF | 0x00 | 0x00 |
| U34 | 0x58 | 0x00 | 0x80 | 0xFF |

Per U34 abilitare le uscite soltanto dopo aver assegnato l'ownership dei segnali condivisi: l'AG32 deve lasciare in alta impedenza i pin che l'expander pilota. In assenza di accordo lasciare i bit condivisi come ingressi. I selettori MEAS_S0–S2 hanno pull-down: non possono generare il livello alto con la sola emulazione open-drain. Occorre pilotaggio push-pull con un solo proprietario alla volta. Anche l'accesso I²C da due controllori richiede arbitraggio/ownership nel firmware.

Ogni cambio funzione deve passare da uno stato intermedio spento: disabilitare lo switch GPIO, spegnere entrambi i MOSFET, attendere l'assestamento, quindi abilitare una sola funzione. Non abilitare mai contemporaneamente P e N. Non alimentare una riga mentre ESP/FPGA o un dispositivo esterno la pilotano. Per ricevere/generare un segnale dalla futura mezzanina: P e N spenti, percorso ESP disabilitato, interfaccia esterna compatibile con tensioni e alimentazioni.

Questa tabella è una specifica di inizializzazione, non firmware già compilato o collaudato. Verificare limiti logici e stato di accensione anche con il modello esatto di expander acquistato e con la futura mezzanina collegata.

## Cosa resta per mezzanina e misure

La revisione del connettore è rinviata come concordato. Le sei porte storiche conservano i collegamenti esistenti. I dieci nuovi segnali e le venti nuove prese Kelvin non sono ancora esportati su J10/J11. Non è quindi ancora possibile usare tutte le 16 righe dall'FPGA della mezzanina attuale. Non sono stati aggiunti INA o DAC alla Backbone.

L'alta impedenza degli switch non elimina capacità parassite, leakage o collegamenti dello stadio di potenza: non è una garanzia di banda analogica. I link 0 Ω permettono di scollegare lo stadio di potenza per configurazioni dedicate; la banda va verificata con la mezzanina e il layout definitivo.

## Meccanica e controlli

PCB preliminare 68 × 68 mm, con magnetici ai lati e antenna ESP al bordo superiore. Tre socket per banco, interasse fra copie 5,08 mm, gap centrale 7,62 mm. Gli interassi delle prime sei posizioni fra J17/J18 e J20/J19 restano 33,02 mm. J10/J11 mantengono 24,175 mm tra centri; la posizione assoluta della mezzanina cambia e va verificata sul suo PCB. I nuovi componenti sono sul top; il modulo ESP/FlexyPin conserva il lato di montaggio originale.

La disposizione è una verifica preliminare di ingombro, non un layout ottimizzato e approvato per integrità di segnale, dissipazione o produzione. Sono ancora da qualificare l'inserimento dal bottom dei socket Hanxia, gli ingombri dei moduli e del case, la regione reale dell'antenna e gli accessi per manutenzione. Non è stato generato uno STEP completo del modulo ESP.

Il controllo della netlist verifica 16 GPIO distinti, 48 contatti di riga, collegamenti nuovi, preservazione delle funzioni e corrispondenza di 930 piazzole del PCB. Sono stati eliminati dalla copia i footprint duplicati e i due header campione fuori scheda. L'ERC mantiene avvisi dei simboli importati (pin non tipizzati) e delle prese di misura non ancora collegate. Il DRC non è pulito: rimangono soprattutto serigrafie, cinque sovrapposizioni dei courtyard dei socket a interasse fisso, anelli FlexyPin da qualificare e rame al bordo dei magnetici. Tutti i collegamenti sono ancora da sbrogliare. Vedere `erc.json` e `drc.json` per l'elenco completo, senza soppressione degli errori.

Il progetto di partenza conteneva soltanto la netclass Default: nella variante sono state ripristinate le 20 classi del controllo di sbroglio precedente ed estese alle nuove reti. Le larghezze sono impostazioni di progetto, non nuove certificazioni della corrente ammessa. Tutti i nuovi R/C usano 0603.

## Reversibilità

Questa cartella è una variante indipendente. Per tornare alla scheda precedente aprire il progetto originale `hardware/backbone/backbone.kicad_pro`. Nessun commit o push è stato eseguito per questa variante.

Schematic: backbone.kicad_sch, SpaghettiLAB - Backbone carrier

Parts:
C1: 100nF/50V; C0603; MPN CL10B104KB8NNNC; LCSC Part Name C1591
C5, C9, C86: 22uF; C_0603_1608Metric; MPN CL10A226MP8NUNE; LCSC Part C86295
C11: 1uF; C0603; LCSC Part Name C128624
C74, C88, C89: 100nF/50V; C0603; MPN CL10B104KB8NNNC; LCSC Part C1591
C84: 22pF; C_0603_1608Metric; MPN CL10C220JB8NNNC; LCSC Part C1653
C85: 100nF/50V; C_0603_1608Metric; MPN CL10B104KB8NNNC; LCSC Part C1591
C125, C126, C127, C128, C129, C130, C132, C133, C134, C135, C136, C137: 100nF/50V; C_0603_1608Metric; MPN CL10B104KB8NNNC; LCSC C1591
C139, C140: 10nF; C_0603_1608Metric; MPN CL10B103KB8NNNC; LCSC C1589
D6: SS54_C22452; SMA_L4.4-W2.8-LS5.4-R-RD; MPN SS54; LCSC Part C22452
D7: BAV70; SOT-23; MPN BAV70; LCSC C68978
H1, H2, H3, H4: MountingHole; MountingHole_2.2mm_M2_DIN965
J1, J140: M20-7810645R
J2: FROM_PREVIOUS; Magnetic_J2_Edge_DualFace
J3: M20-7810645R; DigiKey_Part_Number 952-M20-7810645RCT-ND
J4: SM04B-SRSS-TB(LF)(SN); JST_SH_SM04B-SRSS-TB_1x04-1MP_P1.00mm_Horizontal; MPN SM04B-SRSS-TB(LF)(SN); LCSC C160404
J9: TO NEXT; Magnetic_J9_Edge_DualFace
J10, J11: 61082-061402LF; CONN-SMD_61082-061402LF; LCSC C254696
J15, J16: A2541HWV-2x6P; CJT_A2541HWV-2x6P_P2.54mm_Vertical; MPN A2541HWV-2x6P; LCSC Part C239346
J17, J20: HX PM2.54-1x6P TP-YQ; Hanxia_C42380984_1x06_BottomAccess_Trial; MPN HX PM2.54-1x6P TP-YQ; LCSC C42380984
L1: 3.3uH; L_XRTC404012S; MPN XRTC404012S3R3MBCA; LCSC Part C39846848
LED1, LED2, LED3, LED4, LED5, LED6: SK6812MINI-E; LED_SK6812MINI-E_FR4_Window_HandFormed; MPN SK6812MINI-E; LCSC Part C5149201
Q2: AO3401A; SOT-23_L2.9-W1.3-P1.90-LS2.4-BR; MPN AO3401A; LCSC Part C15127
Q3, Q4, Q5, Q6, Q7, Q8: AO6604; SOT-23-6_L2.9-W1.6-P0.95-LS2.8-BL; MPN AO6604; LCSC C5182068
Q9: LMBT3946DW1T1G; SOT-363_SC-70-6; MPN LMBT3946DW1T1G; LCSC C136169
Q10: LMBT3904DW1T1G; SOT-363_SC-70-6; MPN LMBT3904DW1T1G; LCSC C131781
R4: 10k; R0603; MPN 0603WAF1002T5E; LCSC Part Name C25804
R5: 470R; R0603; MPN 0603WAF4700T5E; LCSC Part Name C23179
R8: 120R; R0603; MPN 0603WAF1200T5E; LCSC Part Name C2906988
R15, R16: 10k; R0603; MPN 0603WAF1002T5E; LCSC Part C25804
R17, R18: 33R; R0603; LCSC Part C2909394
R22, R27: 5.1k; R0603; LCSC Part C2907044
R24, R25: 4.7k; R0603
R36: 150k; R_0603_1608Metric; MPN 0603WAF1503T5E; LCSC Part C22807
R37: 33.2k; R_0603_1608Metric; MPN 0603WAF3322T5E; LCSC Part C23003
R38, R39, R40, R41, R42, R43, R44, R45, R46, R47, R48, R49, R50, R51, R52, R53, R54, R55: 100k; R0603
R56, R57, R58, R59, R60, R61: 0.1R; R_0603_2Terminal_Kelvin; MPN PE0603FRF070R1L; LCSC C1882650
R103, R105, R124, R127, R129, R132: 100k; R_0603_1608Metric; MPN 0603WAF1003T5E; LCSC C25803
R104: 47k; R_0603_1608Metric; MPN 0603WAF4702T5E; LCSC C25819
R110, R111, R115: 100k; R_0603_1608Metric; LCSC C25803
R112, R113, R114: 0R; R_0603_1608Metric; LCSC C21189; not fitted
R117, R118, R119, R120, R121, R122: 0R; R_0603_1608Metric; MPN RC0603JR-070RL; LCSC C95177
R123, R125, R126, R130: 10k; R_0603_1608Metric; MPN 0603WAF1002T5E; LCSC C25804
R128, R131: 22k; R_0603_1608Metric; MPN 0603WAF2202T5E; LCSC C31850
TP15: SMD/0.6mm; TestPoint_Pad_D1.0mm
U1: ESP32-S3-WROOM-1_1U_FlexyPin_Socket
U2: SN65HVD230DR; SOIC-8_L4.9-W3.9-P1.27-LS6.0-BL; MPN SN65HVD230DR; LCSC Part C12084
U3: HC-TYPE-C-16P-01A; USB-C-SMD_HC-TYPE-C-16P-01A; MPN HC-TYPE-C-16P-01A; LCSC Part C2894897
U4: SY8089AAAC; SOT-23-5; MPN SY8089AAAC; LCSC Part C78988
U8: G3VM-61VY3; SMD-4_L4.6-W3.7-P2.54-LS7.0-TL; MPN G3VM-61VY3(TR); LCSC Part C2152318
U12, U13: SN74CBTLV3125PWR; TSSOP-14_L5.0-W4.4-P0.65-LS6.4-BL; LCSC C406866
U25: TCA9535PWR(UMW); TSSOP-24_L7.8-W4.4-P0.65-LS6.4-BL; LCSC C22396388
U26, U27, U28, U29: SN74LVC1G3157DCKR; SOT-363_SC-70-6; LCSC C38663
U31: TS3USB221ARSER; UQFN-10_L2.0-W1.5-P0.50-BL; LCSC C128396

Connections:
5V: C5.1, C85.1, C140.1, D6.2 (K), J2.1, J9.1, J10.1, J10.2, J10.5, J11.1, J11.2, J11.5, Q2.2 (S), Q9.4 (E), R4.1, R125.1, R127.1, R130.1, U4.1 (EN), U4.4 (IN)
/BUCK_FB: C84.2, R36.2, R37.1, U4.5 (FB)
/BUCK_SW: L1.1, U4.3 (LX)
/LED_CHAIN_1: LED1.4 (DOUT), LED2.2 (DIN)
/LED_CHAIN_2: LED2.4 (DOUT), LED3.2 (DIN)
/LED_CHAIN_3: LED3.4 (DOUT), LED4.2 (DIN)
/LED_CHAIN_4: LED4.4 (DOUT), LED5.2 (DIN)
/LED_CHAIN_5: LED5.4 (DOUT), LED6.2 (DIN)
/PWR_DRV_A0: Q3.4 (D), Q3.6 (D), R117.1
/PWR_DRV_A1: Q4.4 (D), Q4.6 (D), R118.1
/PWR_DRV_A2: Q5.4 (D), Q5.6 (D), R119.1
/PWR_DRV_A3: Q6.4 (D), Q6.6 (D), R120.1
/PWR_DRV_A4: Q7.4 (D), Q7.6 (D), R121.1
/PWR_DRV_A5: Q8.4 (D), Q8.6 (D), R122.1
/TERM_DRIVE: Q2.3 (D), R5.2
/TERM_LED: R5.1, U8.1
/TERM_R: R8.2, U8.3
/USB_CC1: R22.1, U3.A5 (CC1)
/USB_CC2: R27.2, U3.B5 (CC2)
A0: J3.7, J10.6, J17.3, U1.7 (IO7), U12.2 (A)
A1: J3.1, J10.9, J17.4, U1.12 (IO8), U12.5 (A)
A2: J3.12, J10.13, J17.5, U1.17 (IO9), U12.9 (A)
A3: J3.10, J10.17, J17.6, U1.18 (IO10), U12.12 (A)
A4: J3.8, J10.21, J20.1, U1.39 (IO1), U13.2 (A)
A5: J3.6, J10.24, J20.4, U1.38 (IO2), U13.5 (A)
A6: U1.6 (IO6), U13.9 (A)
A7: U1.19 (IO11), U13.12 (A)
A8: U1.20 (IO12); also elsewhere on the board
A9: U1.8 (IO15); also elsewhere on the board
A10: U1.9 (IO16); also elsewhere on the board
A11: U1.31 (IO38); also elsewhere on the board
A12: U1.32 (IO39); also elsewhere on the board
A13: U1.33 (IO40); also elsewhere on the board
A14: U1.34 (IO41); also elsewhere on the board
A15: U1.35 (IO42); also elsewhere on the board
AG_CAN_TX: J10.34, U26.1 (B2_AG)
AG_ISO4_N: J10.36, U28.1 (B2_AG)
AG_ISO5_N: J10.37, U29.1 (B2_AG)
AG_LED_DATA: J10.38, U27.1 (B2_AG)
ALED: LED1.2 (DIN), R105.1, U27.4 (A_OUT)
BOOT: J10.28, R15.2, U1.27 (IO0)
CAN_H: J2.2, J9.2, J11.46, R8.1, U2.7 (CANH)
CAN_L: J2.3, J9.3, J11.47, U2.6 (CANL), U8.4
CAN_RX: J10.39, U1.11 (IO18), U2.4 (R)
CAN_TX: R104.2, U2.1 (D), U26.4 (A_OUT)
CTRL13: J10.41, U1.21 (IO13)
CTRL14: J10.42, U1.22 (IO14)
ESP35_AUX: J10.43, R112.2
ESP36_AUX: J10.44, R113.2
ESP37_AUX: J10.46, R114.2
ESP_AG_BOOT0: J10.29; also elsewhere on the board
ESP_AG_RESET_N: J10.31; also elsewhere on the board
ESP_CAN_TX: J10.47, U1.10 (IO17), U26.3 (B1_ESP)
ESP_ISO4_N: J10.48, U28.3 (B1_ESP); also elsewhere on the board
ESP_ISO5_N: J10.49, U29.3 (B1_ESP); also elsewhere on the board
ESP_LED_DATA: J10.51, U1.23 (IO21), U27.3 (B1_ESP)
ESP_PROG_RX: J10.32, U1.25 (IO48)
ESP_PROG_TX: J10.33, U1.24 (IO47)
EXT_SPI_CS_N: J10.52; also elsewhere on the board
GND: C1.2, C5.2, C9.2, C11.1, C74.1, C85.2, C86.2, C88.2, C89.2, C125.2, C126.2, C127.2, C128.2, C129.2, C130.2, C132.2, C133.2, C134.2, C135.2, C136.2, C137.2, C139.2, J2.5, J3.4, J3.5, J3.9, J4.1 (GND), J9.5, J10.15, J10.20, J10.25, J10.30, J10.35, J10.40, J10.45, J10.50, J10.55, J11.15, J11.20, J11.25, J11.30, J11.35, J11.40, J11.45, J11.50, J17.1, J20.2, J20.6, LED1.1 (GND), LED2.1 (GND), LED3.1 (GND), LED4.1 (GND), LED5.1 (GND), LED6.1 (GND), Q3.5 (S), Q4.5 (S), Q5.5 (S), Q6.5 (S), Q7.5 (S), Q8.5 (S), Q9.1 (E), Q10.1 (E), Q10.4 (E), R22.2, R27.1, R37.2, R39.2, R41.2, R43.2, R45.2, R47.2, R49.2, R103.2, R105.2, R111.2, R124.2, R129.2, R132.2, U1.1 (GND), U1.40 (GND), U2.2 (GND), U2.8 (RS), U3.1 (SHELL), U3.2 (SHELL), U3.3 (SHELL), U3.4 (SHELL), U3.A1B12 (GND), U3.B1A12 (GND), U4.2 (GND), U8.2, U12.7 (GND), U13.7 (GND), U25.2 (A1), U25.3 (A2), U25.12 (GND), U25.21 (A0), U26.2 (GND), U27.2 (GND), U28.2 (GND), U29.2 (GND), U31.5 (GND), U31.6 (OE_N); also elsewhere on the board
IO3: J10.53, U1.15 (IO3)
IO4: J4.3 (SDA), J10.54, R24.2, U1.4 (IO4), U25.23 (SDA); also elsewhere on the board
IO5: J4.4 (SCL), J11.7, R25.2, U1.5 (IO5), U25.22 (SCL); also elsewhere on the board
IO35: R112.1, U1.28 (IO35)
IO36: R113.1, U1.29 (IO36)
IO37: R114.1, U1.30 (IO37)
IO45: J10.56, U1.26 (IO45)
IO46: J11.6, U1.16 (IO46)
ISO_A0_N: J11.41, R50.2, U12.1 (~OE), U25.17 (P14)
ISO_A1_N: J11.42, R51.2, U12.4 (~OE), U25.18 (P15)
ISO_A2_N: J11.43, R52.2, U12.10 (~OE), U25.19 (P16)
ISO_A3_N: J11.44, R53.2, U12.13 (~OE), U25.20 (P17)
ISO_A4_N: J11.8, R54.2, U13.1 (~OE), U28.4 (A_OUT)
ISO_A5_N: J11.9, R55.2, U13.4 (~OE), U29.4 (A_OUT)
ISO_A6_N: U13.10 (~OE); also elsewhere on the board
ISO_A7_N: U13.13 (~OE); also elsewhere on the board
LED_EXP_DATA: J11.52, LED6.4 (DOUT)
MEAS_INHIBIT: J11.11; also elsewhere on the board
MEAS_S0: J11.12; also elsewhere on the board
MEAS_S1: J11.13; also elsewhere on the board
MEAS_S2: J11.14; also elsewhere on the board
MEZZ_OWNER: J11.16, R103.1, U26.6 (S_AG_READY), U27.6 (S_AG_READY), U28.6 (S_AG_READY), U29.6 (S_AG_READY), U31.9 (S_MEZZ)
MEZZ_PRESENT_N: J11.17, R115.2; also elsewhere on the board
N_A0: J10.7, R56.1, R117.2, U12.3 (B)
N_A1: J10.11, R57.1, R118.2, U12.6 (B)
N_A2: J10.14, R58.1, R119.2, U12.8 (B)
N_A3: J10.18, R59.1, R120.2, U12.11 (B)
N_A4: J10.22, R60.1, R121.2, U13.3 (B)
N_A5: J10.26, R61.1, R122.2, U13.6 (B)
N_A6: U13.8 (B); also elsewhere on the board
N_A7: U13.11 (B); also elsewhere on the board
N_GATE_0: J11.27, Q3.1 (G), R39.1, U25.5 (P01)
N_GATE_1: J11.29, Q4.1 (G), R41.1, U25.7 (P03)
N_GATE_2: J11.32, Q5.1 (G), R43.1, U25.9 (P05)
N_GATE_3: J11.34, Q6.1 (G), R45.1, U25.11 (P07)
N_GATE_4: J11.37, Q7.1 (G), R47.1, U25.14 (P11)
N_GATE_5: J11.39, Q8.1 (G), R49.1, U25.16 (P13)
PORT_A0: J1.1, J1.2, J10.8, J140.1, J140.2, R56.2; also elsewhere on the board
PORT_A1: J1.3, J1.4, J10.12, J140.3, J140.4, R57.2; also elsewhere on the board
PORT_A2: J1.5, J1.6, J10.16, J140.5, J140.6, R58.2; also elsewhere on the board
PORT_A3: J1.7, J1.8, J10.19, J140.7, J140.8, R59.2; also elsewhere on the board
PORT_A4: J1.9, J1.10, J10.23, J140.9, J140.10, R60.2; also elsewhere on the board
PORT_A5: J1.11, J1.12, J10.27, J140.11, J140.12, R61.2; also elsewhere on the board
P_GATE_0: J11.26, Q3.3 (G), R38.2, U25.4 (P00)
P_GATE_1: J11.28, Q4.3 (G), R40.2, U25.6 (P02)
P_GATE_2: J11.31, Q5.3 (G), R42.2, U25.8 (P04)
P_GATE_3: J11.33, Q6.3 (G), R44.2, U25.10 (P06)
P_GATE_4: J11.36, Q7.3 (G), R46.2, U25.13 (P10)
P_GATE_5: J11.38, Q8.3 (G), R48.2, U25.15 (P12)
SHUNT_SENSE_H0: J10.57, R56.3
SHUNT_SENSE_H1: J10.59, R57.3
SHUNT_SENSE_H2: J11.53, R58.3
SHUNT_SENSE_H3: J11.55, R59.3
SHUNT_SENSE_H4: J11.57, R60.3
SHUNT_SENSE_H5: J11.59, R61.3
SHUNT_SENSE_L0: J10.58, R56.4
SHUNT_SENSE_L1: J10.60, R57.4
SHUNT_SENSE_L2: J11.54, R58.4
SHUNT_SENSE_L3: J11.56, R59.4
SHUNT_SENSE_L4: J11.58, R60.4
SHUNT_SENSE_L5: J11.60, R61.4
SPI_MISO: J11.18, U1.36 (RXD0)
SPI_MOSI: J11.19, U1.37 (TXD0)
TERM_ABSENT_L: D7.1 (A), Q9.6 (C), R125.2
TERM_ABSENT_OR: D7.3 (K), R131.1
TERM_ABSENT_R: D7.2 (A), Q10.6 (C), R130.2
TERM_BASE_DRIVE: Q10.5 (B), R131.2, R132.1
TERM_BASE_INV: Q10.2 (B), R128.2, R129.1
TERM_BASE_L: C139.1, Q9.2 (B), R123.2, R124.1
TERM_BASE_R: C140.2, Q9.5 (B), R126.2, R127.2
TERM_CTRL_IN: J2.4, J11.48, R123.1
TERM_CTRL_OUT: J9.4, J11.49, R126.1
TERM_GATE_N: Q2.1 (G), Q10.3 (C), R4.2
TERM_PRESENT_R: Q9.3 (C), R128.1
USB_D+: U3.A6 (D+), U3.B6 (D+), U31.8 (USB_D+)
USB_D-: U3.A7 (D-), U3.B7 (D-), U31.7 (USB_D-)
USB_ESP_D+: R17.2, U1.14 (USB_D+)
USB_ESP_D-: R18.2, U1.13 (USB_D-)
USB_SW_AG_N: J11.21, U31.4 (AG_D-)
USB_SW_AG_P: J11.22, U31.3 (AG_D+)
USB_SW_ESP_N: R18.1, U31.2 (ESP_D-)
USB_SW_ESP_P: R17.1, U31.1 (ESP_D+)
USB_VBUS_SENSE: J11.23, R110.2, R111.1
VBUS: D6.1 (A), J11.51, R110.1, U3.A4B9 (VBUS), U3.B4A9 (VBUS)
VCORE: C1.1, C9.1, C74.2, C84.1, C86.1, C88.1, C89.1, C125.1, C126.1, C127.1, C128.1, C129.1, C130.1, C132.1, C133.1, C134.1, C135.1, C136.1, C137.1, J3.2, J3.3, J3.11, J4.2 (+3V3), J10.3, J10.4, J10.10, J11.3, J11.4, J11.10, J17.2, J20.3, J20.5, L1.2, LED1.3 (VDD), LED2.3 (VDD), LED3.3 (VDD), LED4.3 (VDD), LED5.3 (VDD), LED6.3 (VDD), Q3.2 (S), Q4.2 (S), Q5.2 (S), Q6.2 (S), Q7.2 (S), Q8.2 (S), R15.1, R16.1, R24.1, R25.1, R36.1, R38.1, R40.1, R42.1, R44.1, R46.1, R48.1, R50.1, R51.1, R52.1, R53.1, R54.1, R55.1, R104.1, R115.1, TP15.1 (1_1), U1.2 (3V3), U2.3 (VCC), U12.14 (VCC), U13.14 (VCC), U25.24 (VCC), U26.5 (VCC), U27.5 (VCC), U28.5 (VCC), U29.5 (VCC), U31.10 (VCC); also elsewhere on the board
~RESET: C11.2, J11.24, R16.2, U1.3 (EN)

Notes on the sheet:
J3 | DIRECT ESP32 ACCESS
is USB voltage, not 3.3 V logic.
U1 | OPTIONAL ESP32-S3
U26-U29 | AUTOMATIC CONTROLLER SELECTION
U25 | PORT CONFIGURATION
Bottom insertion | 20.72 x 5 x 5 mm | land pattern requires physical qualification
USB-C + U31 | COMPUTER CONNECTION
Powers the carrier and the removable Expansion module.
Connects compatible sensors through a four-wire cable.
J4 | QWIIC SENSOR LINK
P1-P6 = external experiment rows | A0-A5 = ESP-side signals | J3 = separate direct access. Named arrows connect blocks.
U2 | CAN TRANSCEIVER
Adds Wi-Fi, Bluetooth and familiar ESP32 development tools.
LED1-LED6 | PORT STATUS
Six configurable ports. Header and serial LED order: P1-P6.
Gives Expansion priority; the base uses ESP32 when no module is fitted.
Unconnected mechanical samples. Not fitted in production.
READING GUIDE: Q3-Q8 = power stages | U12/U13 = signal isolation | J1/J140 = shared headers | R56-R61 = shunts
INTERFACE V3: 120/120 assigned | 17 GND | 6 x 5V | 6 x VCORE | 12 dedicated shunt sense | all services retained.
Passes power and messages between neighbouring backbones.
Physical IC groups | all units of each IC together | named nets preserve functional links
GPIO35/36/37 AUX links are DNP PSRAM guards. Fit only on compatible ESP32 variants. USB does not pass through FPGA logic.
Q9/Q10 detect both neighbours by TERM current. Q2/U8 insert 120R at either end. No MCU.
2 x 6 contacts | 2.54 mm pitch | body 15.74 x 5.00 x 8.50 mm
MEZZ_OWNER LOW = ESP32, HIGH = Expansion. R103 = 100k pull-down; Expansion adds R109 = 10k pull-up. Claim is not firmware-ready. USB, CAN TX, RGB and ISO4/5 are selected.
CJT CONNECTOR FIT TEST | J15 / J16
J2 / J9 | MAGNETIC CAN LINK
U31: LOW selects ESP32, HIGH selects Expansion. Both USB series-resistor pairs are fitted. Owner changes require USB detach and re-enumeration.
Shared I2C control of the six power stages.
Added gate / ISO signals are shared with U25: release its outputs before external drive. VBUS
Provides fixed ESP32, supply and ground connections.
Connects USB to the selected controller.
J17 / J20: direct ESP sensor rows, A0-A5 plus mixed 3V3 / GND. J18 / J19: configurable P1-P6.
SPAGHETTILAB | BACKBONE CARRIER
U4 | 5 V TO 3.3 V SUPPLY
J10 / J11 | EXPANSION INTERFACE - 2 x 60 CONTACTS
BKL 2x8 DUAL ENTRY | SENSOR & CONFIGURABLE HEADERS
Turns controller messages into CAN bus signals.
U25 + C129: common to all variants. One active I2C master at a time. U12/U13 are grouped separately below.
P1 | Q3 POWER STAGE

Schematic: ports16.kicad_sch

Parts:
C141, C142, C143, C144, C145: 100nF/50V; C0603; MPN CL10B104KB8NNNC; LCSC Part C1591
J18, J19, J21, J22, J23, J24: HX PM2.54-1x8P TP-YQ; Hanxia_C42380985_1x08_BottomAccess_Trial; MPN HX PM2.54-1x6P TP-YQ; LCSC C42380985
Q11, Q12, Q13, Q14, Q15, Q16, Q17, Q18, Q19, Q20: AO6604; SOT-23-6_L2.9-W1.6-P0.95-LS2.8-BL; MPN AO6604; LCSC C5182068
R133, R134, R135, R136, R137, R138, R139, R140, R141, R142: 0.1R; R_0603_2Terminal_Kelvin; MPN PE0603FRF070R1L; LCSC C1882650
R143, R144, R145, R146, R147, R148, R149, R150, R151, R152, R153, R154, R155, R156, R157, R158, R159, R160, R161, R162, R163, R164, R165, R166, R167, R168, R169, R170, R171, R172, R183, R184, R185, R186, R187, R188, R189: 100k; R0603
R173, R174, R175, R176, R177, R178, R179, R180, R181, R182: 0R; R_0603_1608Metric; MPN RC0603JR-070RL; LCSC C95177
U32, U33, U34: TCA9535PWR(UMW); TSSOP-24_L7.8-W4.4-P0.65-LS6.4-BL; LCSC C22396388
U35, U36: SN74CBTLV3125PWR; TSSOP-14_L5.0-W4.4-P0.65-LS6.4-BL; LCSC C406866

Connections:
A8: U35.2 (A); also elsewhere on the board
A9: U35.5 (A); also elsewhere on the board
A10: U35.9 (A); also elsewhere on the board
A11: U35.12 (A); also elsewhere on the board
A12: U36.2 (A); also elsewhere on the board
A13: U36.5 (A); also elsewhere on the board
A14: U36.9 (A); also elsewhere on the board
A15: U36.12 (A); also elsewhere on the board
DRIVER_A6: Q11.4 (D), Q11.6 (D), R173.1
DRIVER_A7: Q12.4 (D), Q12.6 (D), R174.1
DRIVER_A8: Q13.4 (D), Q13.6 (D), R175.1
DRIVER_A9: Q14.4 (D), Q14.6 (D), R176.1
DRIVER_A10: Q15.4 (D), Q15.6 (D), R177.1
DRIVER_A11: Q16.4 (D), Q16.6 (D), R178.1
DRIVER_A12: Q17.4 (D), Q17.6 (D), R179.1
DRIVER_A13: Q18.4 (D), Q18.6 (D), R180.1
DRIVER_A14: Q19.4 (D), Q19.6 (D), R181.1
DRIVER_A15: Q20.4 (D), Q20.6 (D), R182.1
ESP_AG_BOOT0: R188.2, U34.9 (P05); also elsewhere on the board
ESP_AG_RESET_N: R189.2, U34.10 (P06); also elsewhere on the board
ESP_ISO4_N: U33.19 (P16); also elsewhere on the board
ESP_ISO5_N: U33.20 (P17); also elsewhere on the board
EXT_SPI_CS_N: R187.2, U34.8 (P04); also elsewhere on the board
GND: C141.2, C142.2, C143.2, C144.2, C145.2, Q11.5 (S), Q12.5 (S), Q13.5 (S), Q14.5 (S), Q15.5 (S), Q16.5 (S), Q17.5 (S), Q18.5 (S), Q19.5 (S), Q20.5 (S), R144.2, R146.2, R148.2, R150.2, R152.2, R154.2, R156.2, R158.2, R160.2, R162.2, R183.1, R184.1, R185.1, R188.1, U32.2 (A1), U32.3 (A2), U32.12 (GND), U33.3 (A2), U33.12 (GND), U33.21 (A0), U34.3 (A2), U34.12 (GND), U34.13 (P10), U34.14 (P11), U34.15 (P12), U34.16 (P13), U34.17 (P14), U34.18 (P15), U34.19 (P16), U34.20 (P17), U35.7 (GND), U36.7 (GND); also elsewhere on the board
IO4: U32.23 (SDA), U33.23 (SDA), U34.23 (SDA); also elsewhere on the board
IO5: U32.22 (SCL), U33.22 (SCL), U34.22 (SCL); also elsewhere on the board
ISO_A6_N: R163.2, U33.8 (P04); also elsewhere on the board
ISO_A7_N: R164.2, U33.9 (P05); also elsewhere on the board
ISO_A8_N: R165.2, U33.10 (P06), U35.1 (~OE)
ISO_A9_N: R166.2, U33.11 (P07), U35.4 (~OE)
ISO_A10_N: R167.2, U33.13 (P10), U35.10 (~OE)
ISO_A11_N: R168.2, U33.14 (P11), U35.13 (~OE)
ISO_A12_N: R169.2, U33.15 (P12), U36.1 (~OE)
ISO_A13_N: R170.2, U33.16 (P13), U36.4 (~OE)
ISO_A14_N: R171.2, U33.17 (P14), U36.10 (~OE)
ISO_A15_N: R172.2, U33.18 (P15), U36.13 (~OE)
MEAS_INHIBIT: R186.2, U34.7 (P03); also elsewhere on the board
MEAS_S0: R183.2, U34.4 (P00); also elsewhere on the board
MEAS_S1: R184.2, U34.5 (P01); also elsewhere on the board
MEAS_S2: R185.2, U34.6 (P02); also elsewhere on the board
MEZZ_PRESENT_N: U34.11 (P07); also elsewhere on the board
N_A6: R133.1, R173.2; also elsewhere on the board
N_A7: R134.1, R174.2; also elsewhere on the board
N_A8: R135.1, R175.2, U35.3 (B)
N_A9: R136.1, R176.2, U35.6 (B)
N_A10: R137.1, R177.2, U35.8 (B)
N_A11: R138.1, R178.2, U35.11 (B)
N_A12: R139.1, R179.2, U36.3 (B)
N_A13: R140.1, R180.2, U36.6 (B)
N_A14: R141.1, R181.2, U36.8 (B)
N_A15: R142.1, R182.2, U36.11 (B)
N_GATE_6: Q11.1 (G), R144.1, U32.5 (P01)
N_GATE_7: Q12.1 (G), R146.1, U32.7 (P03)
N_GATE_8: Q13.1 (G), R148.1, U32.9 (P05)
N_GATE_9: Q14.1 (G), R150.1, U32.11 (P07)
N_GATE_10: Q15.1 (G), R152.1, U32.14 (P11)
N_GATE_11: Q16.1 (G), R154.1, U32.16 (P13)
N_GATE_12: Q17.1 (G), R156.1, U32.18 (P15)
N_GATE_13: Q18.1 (G), R158.1, U32.20 (P17)
N_GATE_14: Q19.1 (G), R160.1, U33.5 (P01)
N_GATE_15: Q20.1 (G), R162.1, U33.7 (P03)
PORT_A0: J18.1, J19.1, J21.1; also elsewhere on the board
PORT_A1: J18.2, J19.2, J21.2; also elsewhere on the board
PORT_A2: J18.3, J19.3, J21.3; also elsewhere on the board
PORT_A3: J18.4, J19.4, J21.4; also elsewhere on the board
PORT_A4: J18.5, J19.5, J21.5; also elsewhere on the board
PORT_A5: J18.6, J19.6, J21.6; also elsewhere on the board
PORT_A6: J18.7, J19.7, J21.7, R133.2
PORT_A7: J18.8, J19.8, J21.8, R134.2
PORT_A8: J22.1, J23.1, J24.1, R135.2
PORT_A9: J22.2, J23.2, J24.2, R136.2
PORT_A10: J22.3, J23.3, J24.3, R137.2
PORT_A11: J22.4, J23.4, J24.4, R138.2
PORT_A12: J22.5, J23.5, J24.5, R139.2
PORT_A13: J22.6, J23.6, J24.6, R140.2
PORT_A14: J22.7, J23.7, J24.7, R141.2
PORT_A15: J22.8, J23.8, J24.8, R142.2
P_GATE_6: Q11.3 (G), R143.2, U32.4 (P00)
P_GATE_7: Q12.3 (G), R145.2, U32.6 (P02)
P_GATE_8: Q13.3 (G), R147.2, U32.8 (P04)
P_GATE_9: Q14.3 (G), R149.2, U32.10 (P06)
P_GATE_10: Q15.3 (G), R151.2, U32.13 (P10)
P_GATE_11: Q16.3 (G), R153.2, U32.15 (P12)
P_GATE_12: Q17.3 (G), R155.2, U32.17 (P14)
P_GATE_13: Q18.3 (G), R157.2, U32.19 (P16)
P_GATE_14: Q19.3 (G), R159.2, U33.4 (P00)
P_GATE_15: Q20.3 (G), R161.2, U33.6 (P02)
SHUNT_SENSE_H6: R133.3
SHUNT_SENSE_H7: R134.3
SHUNT_SENSE_H8: R135.3
SHUNT_SENSE_H9: R136.3
SHUNT_SENSE_H10: R137.3
SHUNT_SENSE_H11: R138.3
SHUNT_SENSE_H12: R139.3
SHUNT_SENSE_H13: R140.3
SHUNT_SENSE_H14: R141.3
SHUNT_SENSE_H15: R142.3
SHUNT_SENSE_L6: R133.4
SHUNT_SENSE_L7: R134.4
SHUNT_SENSE_L8: R135.4
SHUNT_SENSE_L9: R136.4
SHUNT_SENSE_L10: R137.4
SHUNT_SENSE_L11: R138.4
SHUNT_SENSE_L12: R139.4
SHUNT_SENSE_L13: R140.4
SHUNT_SENSE_L14: R141.4
SHUNT_SENSE_L15: R142.4
VCORE: C141.1, C142.1, C143.1, C144.1, C145.1, Q11.2 (S), Q12.2 (S), Q13.2 (S), Q14.2 (S), Q15.2 (S), Q16.2 (S), Q17.2 (S), Q18.2 (S), Q19.2 (S), Q20.2 (S), R143.1, R145.1, R147.1, R149.1, R151.1, R153.1, R155.1, R157.1, R159.1, R161.1, R163.1, R164.1, R165.1, R166.1, R167.1, R168.1, R169.1, R170.1, R171.1, R172.1, R186.1, R187.1, R189.1, U32.21 (A0), U32.24 (VCC), U33.2 (A1), U33.24 (VCC), U34.2 (A1), U34.21 (A0), U34.24 (VCC), U35.14 (VCC), U36.14 (VCC); also elsewhere on the board

Notes on the sheet:
U32: I2C 0x21 / port controls
U33: I2C 0x22 / port controls
U34: I2C 0x23 / slow services; presence input
PORT 7 / L7 / GPIO6
GPIO switch: U13C on main sheet
PORT 8 / L8 / GPIO11
GPIO switch: U13D on main sheet
PORT 9 / R1 / GPIO12
PORT 10 / R2 / GPIO15
PORT 11 / R3 / GPIO16
PORT 12 / R4 / GPIO38
PORT 13 / R5 / GPIO39
PORT 14 / R6 / GPIO40
PORT 15 / R7 / GPIO41
PORT 16 / R8 / GPIO42
LEFT L1-L8 / 3 contacts per independent node
RIGHT R1-R8 / 3 contacts per independent node
VCORE = 3.3 V. Disable GPIO path before selecting a rail. Never enable both MOSFETs. No crosspoint matrix. Firmware and mezzanine interface revision required. Existing six shunts retained; ten added sense pairs are local only until the interface is redesigned.

Board: 4 copper layers, 212 parts (1 on the bottom side), 202 nets, no tracks yet.

## KiCad design hardware/backbone/mezzanine/expansion/expansion.kicad_pcb

File hardware/README.md:

# Hardware sources

The Community repository tracks the editable KiCad projects required to study,
modify and build the public hardware: project, schematic, PCB, symbol, footprint
and related source assets.

Generated manufacturing outputs are intentionally not tracked. This includes
`production/` directories, Gerber and drill files, pick-and-place exports, BOMs,
netlists, fabrication ZIP archives and fabrication-toolkit local options. Generate
them from the reviewed KiCad sources when needed; official manufacturing releases
and production controls are maintained separately.

The ignore rules do not provide confidentiality for files already published in Git
history. They only prevent generated outputs from being added in future commits.

## Backbone V3

Open the [Backbone V3 KiCad project](backbone-v3/backbone-v3.kicad_pro) or the [interactive front panel preview](backbone-v3/anteprima-interattiva.html).

## KiCad library policy

Each public schematic embeds the symbols it uses and each public PCB embeds its
placed footprints, so the existing designs can be opened and edited without the
private Production repository. External 3D models are optional visualization assets:
missing models must not prevent schematic or PCB work.

Do not copy vendor 3D models or global workstation libraries into Community until
their origin and redistribution licence are recorded. New reusable public symbols or
footprints should be added as project-local, redistributable source assets rather
than relying on a developer's global KiCad configuration.

Schematic: expansion.kicad_sch, SpaghettiLAB - Expansion

Parts:
C90, C91, C92, C93, C94, C95, C96, C97, C98, C100, C101, C121, C122, C123, C131: 100nF; C_0603_1608Metric; LCSC C14663
C99: 1uF; C_0603_1608Metric; LCSC C15849
J5: FH12-24S-0.5SH(55); Hirose_FH12-24S-0.5SH_1x24-1MP_P0.50mm_Horizontal; LCSC C202112
J10, J11: 61083-061402LF; CONN-SMD_61083-061402LF; LCSC C464610
J12: ESP_AUX_24; PinHeader_2x12_P2.54mm_Vertical_SMD
R70, R72, R73, R79, R80, R83, R84, R109: 10k; R_0603_1608Metric; LCSC C25804
R71, R74, R75, R76, R78: 100k; R_0603_1608Metric; LCSC C25803
R77: 4.7k 0.1% 25ppm; R_0603_1608Metric; LCSC C513565
R81, R82: 22R; R_0603_1608Metric; LCSC C23345
R85, R86, R87, R88: 1k; R_0603_1608Metric; LCSC C21190
R107: 10k; R_0603_1608Metric; MPN 0603WAF1002T5E; LCSC C25804
R108: 100k; R_0603_1608Metric; MPN 0603WAF1003T5E; LCSC C25803
R116: 0R; R_0603_1608Metric; LCSC C21189
TP18, TP19, TP21: SMD/0.6mm; TestPoint_Pad_D1.0mm
TP22: AG_NRST; TestPoint_Pad_D1.0mm
TP23: AG_JTMS; TestPoint_Pad_D1.0mm
TP24: AG_JTCK; TestPoint_Pad_D1.0mm
TP25: AG_JTDI; TestPoint_Pad_D1.0mm
TP26: AG_JTDO; TestPoint_Pad_D1.0mm
TP27: AG_JNTRST; TestPoint_Pad_D1.0mm
TP41: DAC1_SPARE; TestPoint_Pad_D1.0mm
TP42: SPARE_IO_17; TestPoint_Pad_D1.0mm
TP43: SPARE_IO_33; TestPoint_Pad_D1.0mm
TP44: SPARE_IO_34; TestPoint_Pad_D1.0mm
TP45: ISO4_CTRL; TestPoint_Pad_D1.0mm
TP46: ISO5_CTRL; TestPoint_Pad_D1.0mm
TP47: AG_UART_RX; TestPoint_Pad_D1.0mm
TP48: AG_UART_TX; TestPoint_Pad_D1.0mm
TP49: AG_BOOT0; TestPoint_Pad_D1.0mm
U14: AG32VF407VGT6; LQFP-100_L14.0-W14.0-P0.50-LS16.0-TL; LCSC C5336269
U16: INA226AIDGSR; MSOP-10_L3.0-W3.0-P0.50-LS5.0-BL; LCSC C49851
U17, U18, U19: 74HC4051BQ,115; DHVQFN-16_L3.5-W2.5-P0.50-BL-EP; LCSC C128429
U32: DAC_R77_BYPASS; SOT-363_SC-70-6; LCSC C38663
X1: 20MHz; OSC-SMD_4P-L3.2-W2.5-BL; LCSC C390499

Connections:
5V: J10.1, J10.2, J11.1, J11.2, J12.22
/AG_BOOT0: R83.2, R87.2, TP49.1, U14.94 (BOOT0)
/AG_BOOT1: R84.2, U14.37 (BOOT1)
/AG_JNTRST_N: R73.2, TP27.1 (1_1), U14.90 (JNTRST_N)
/AG_JTCK: TP24.1 (1_1), U14.76 (JTCK)
/AG_JTDI: TP25.1 (1_1), U14.77 (JTDI)
/AG_JTDO: TP26.1 (1_1), U14.89 (JTDO)
/AG_JTMS: TP23.1 (1_1), U14.72 (JTMS)
/AG_NRST_N: C92.1, R72.2, R88.2, TP22.1 (1_1), U14.14 (NRST_N)
/CLK20M: U14.12 (OSC_IN), U14.18 (CLK20M_FPGA), X1.3 (OUT)
/DAC1_SPARE: J5.22, TP41.1 (1_1), U14.30 (DAC1_SPARE)
/DAC_INHIBIT: R71.2, U14.81 (DAC_INHIBIT), U19.6 (E_INHIBIT)
/DAC_S0: U14.78 (DAC_S0), U19.11 (S0)
/DAC_S1: U14.79 (DAC_S1), U19.10 (S1)
/DAC_S2: U14.80 (DAC_S2), U19.9 (S2)
/INA_ALERT_N: R76.2, U14.84 (INA_ALERT_N), U16.3 (Alert)
/SHUNT_HIGH_SELECTED: U16.10 (VIN+), U17.3 (Z)
/SHUNT_LOW_SELECTED: U16.8 (VBUS), U16.9 (VIN-), U18.3 (Z)
/SPARE_IO_17: TP42.1 (1_1), U14.17 (ADC_IN12_SPARE)
/SPARE_IO_33: TP43.1 (1_1), U14.33 (ADC_IN14_SPARE)
/SPARE_IO_34: TP44.1 (1_1), U14.34 (ADC_IN15_SPARE)
/USB_AG_D+: R82.1, U14.71 (USB_DP)
/USB_AG_D-: R81.1, U14.70 (USB_DM)
A0: J10.6, J12.6, U14.38 (ESP_A0)
A1: J10.9, J12.7, U14.39 (ESP_A1)
A2: J10.13, J12.8, U14.40 (ESP_A2)
A3: J10.17, J12.9, U14.41 (ESP_A3)
A4: J10.21, J12.10, U14.42 (ESP_A4)
A5: J10.24, J12.11, U14.43 (ESP_A5)
AG_BOOT_UART_RX: R85.2, TP47.1, U14.69 (ISO5_N)
AG_BOOT_UART_TX: R86.1, TP48.1, U14.68 (ISO4_N)
AG_CAN_TX: J10.34, U14.92 (CAN_TX)
AG_ISO4_N: J10.36, U14.35 (ADC_IN8_SPARE)
AG_ISO5_N: J10.37, U14.36 (ADC_IN9_SPARE)
AG_LED_DATA: J10.38, U14.7 (LED_DATA)
BOOT: J10.28, J12.1, U14.61 (N_GATE4)
CAN_H: J11.46
CAN_L: J11.47
CAN_RX: J5.8, J10.39, U14.93 (CAN_RX)
CTRL13: J10.41, J12.12, R74.2, U14.86 (SPI_CS_N)
CTRL14: J5.19, J10.42, U14.87 (SPI_SCLK)
DAC_BYPASS_N: R78.2, U14.85 (DAC_BYPASS_N), U32.6 (S_AG_READY)
DAC_LIMITED: R77.2, U14.16 (ADC_LIMIT/IN11), U19.3 (Z), U32.4 (A_OUT)
DAC_RAW: R77.1, U14.15 (ADC_RAW/IN10), U14.29 (DAC0_OUT), U32.3 (B1_ESP)
ESP35_AUX: J10.43, J12.13, U14.64 (ISO0_N)
ESP36_AUX: J10.44, J12.14, U14.65 (ISO1_N)
ESP37_AUX: J10.46, J12.15, U14.66 (ISO2_N)
ESP_AG_BOOT0: J10.29, J12.2, R87.1, U14.67 (ISO3_N)
ESP_AG_RESET_N: J10.31, J12.3, R88.1, U14.82 (INA_SDA)
ESP_CAN_TX: J5.7, J10.47, U14.55 (N_GATE1)
ESP_ISO4_N: J5.12, J10.48, U14.56 (P_GATE2_N)
ESP_ISO5_N: J5.13, J10.49, U14.57 (N_GATE2)
ESP_LED_DATA: J5.9, J10.51, U14.58 (P_GATE3_N)
ESP_PROG_RX: J10.32, J12.4, R86.2, U14.83 (INA_SCL)
ESP_PROG_TX: J10.33, J12.5, R85.1, U14.54 (P_GATE1_N)
EXT_SPI_CS_N: J5.4, J10.52, R108.1, U14.60 (P_GATE4_N)
GND: C90.2, C91.2, C92.2, C93.2, C94.2, C95.2, C96.2, C97.2, C98.2, C99.2, C100.2, C101.2, C121.2, C122.2, C123.2, C131.2, J5.1, J5.6, J5.10, J5.14, J5.24, J10.5, J10.10, J10.15, J10.20, J10.25, J10.30, J10.35, J10.40, J10.45, J10.50, J10.55, J10.57, J10.58, J10.59, J10.60, J11.5, J11.10, J11.15, J11.20, J11.25, J11.30, J11.35, J11.40, J11.45, J11.50, J11.55, J11.57, J11.58, J11.59, J11.60, J12.20, J12.23, R83.1, R84.1, R116.2, TP21.1 (1_1), U14.10 (VSS33), U14.20 (VSSA), U14.27 (VSS33), U14.74 (VSS33), U14.99 (VSS33), U16.1 (A1), U16.2 (A0), U16.7 (GND), U17.7 (VEE), U17.8 (GND), U18.7 (VEE), U18.8 (GND), U19.7 (VEE), U19.8 (GND), U32.2 (GND), X1.2 (GND)
IO3: J10.53, J12.16, R75.2, U14.97 (ESP_IRQ_N)
IO4: J5.17, J10.54, U14.95 (EXT_I2C_SDA), U16.4 (SDA)
IO5: J5.18, J11.7, U14.96 (EXT_I2C_SCL), U16.5 (SCL)
IO45: J10.56, J12.17, U14.62 (P_GATE5_N)
IO46: J11.6, J12.18, U14.63 (N_GATE5)
ISO_A0_N: J11.41
ISO_A1_N: J11.42
ISO_A2_N: J11.43
ISO_A3_N: J11.44
ISO_A4_N: J11.8, TP45.1 (1_1)
ISO_A5_N: J11.9, TP46.1 (1_1)
LED_EXP_DATA: J11.52
MEAS_INHIBIT: J5.16, J11.11, R70.2, U14.5 (MEAS_INHIBIT), U17.6 (E_INHIBIT), U18.6 (E_INHIBIT)
MEAS_S0: J5.3, J11.12, R79.2, U14.2 (MEAS_S0), U17.11 (S0), U18.11 (S0)
MEAS_S1: J5.5, J11.13, R80.2, U14.3 (MEAS_S1), U17.10 (S1), U18.10 (S1)
MEAS_S2: J5.15, J11.14, R107.1, U14.4 (MEAS_S2), U17.9 (S2), U18.9 (S2)
MEZZ_OWNER: J11.16, R109.2, U14.52 (P_GATE0_N)
MEZZ_PRESENT_N: J5.11, J11.17, R116.1, U14.59 (N_GATE3)
N_A0: J10.7, U14.44 (DRIVE_A0), U17.13 (Y0), U19.13 (Y0)
N_A1: J10.11, U14.45 (DRIVE_A1), U17.14 (Y1), U19.14 (Y1)
N_A2: J10.14, U14.46 (DRIVE_A2), U17.15 (Y2), U19.15 (Y2)
N_A3: J10.18, U14.47 (DRIVE_A3), U17.12 (Y3), U19.12 (Y3)
N_A4: J10.22, U14.48 (DRIVE_A4), U17.1 (Y4), U19.1 (Y4)
N_A5: J10.26, U14.51 (DRIVE_A5), U17.5 (Y5), U19.5 (Y5)
N_GATE_0: J11.27
N_GATE_1: J11.29
N_GATE_2: J11.32
N_GATE_3: J11.34
N_GATE_4: J11.37
N_GATE_5: J11.39
PORT_A0: J10.8, U14.23 (ADC_A0/IN0), U18.13 (Y0)
PORT_A1: J10.12, U14.24 (ADC_A1/IN1), U18.14 (Y1)
PORT_A2: J10.16, U14.25 (ADC_A2/IN2), U18.15 (Y2)
PORT_A3: J10.19, U14.26 (ADC_A3/IN3), U18.12 (Y3)
PORT_A4: J10.23, U14.31 (ADC_A4/IN6), U18.1 (Y4)
PORT_A5: J10.27, U14.32 (ADC_A5/IN7), U18.5 (Y5)
P_GATE_0: J11.26
P_GATE_1: J11.28
P_GATE_2: J11.31
P_GATE_3: J11.33
P_GATE_4: J11.36
P_GATE_5: J11.38
SPI_MISO: J5.21, J11.18, TP18.1 (1_1), U14.91 (SPI_MISO)
SPI_MOSI: J5.20, J11.19, TP19.1 (1_1), U14.88 (SPI_MOSI)
TERM_CTRL_IN: J11.48
TERM_CTRL_OUT: J11.49
USB_SW_AG_N: J11.21, R81.2
USB_SW_AG_P: J11.22, R82.2
USB_VBUS_SENSE: J11.23, U14.53 (N_GATE0)
VBUS: J11.51
VCORE: C90.1, C91.1, C93.1, C94.1, C95.1, C96.1, C97.1, C98.1, C99.1, C100.1, C101.1, C121.1, C122.1, C123.1, C131.1, J5.2, J5.23, J10.3, J10.4, J11.3, J11.4, J12.21, R70.1, R71.1, R72.1, R73.1, R74.1, R75.1, R76.1, R78.1, R79.1, R80.1, R107.2, R108.2, R109.1, U14.6 (VBAT), U14.11 (VDD33), U14.21 (VREFP), U14.22 (VDDA), U14.28 (VDD33), U14.50 (VDD33), U14.75 (VDD33), U14.100 (VDD33), U16.6 (VS+), U17.16 (VCC), U17.17 (EP_VCC), U18.16 (VCC), U18.17 (EP_VCC), U19.16 (VCC), U19.17 (EP_VCC), U32.5 (VCC), X1.1 (OE/#ST), X1.4 (VCC)
~RESET: J11.24, J12.19, U14.98 (ESP_RESET_OD)

Notes on the sheet:
U14D + U16-U18 | SHARED CURRENT MONITOR
Selects one experiment row at a time and reads its shunt voltage.
Match both mux channel selections. Inhibit, select, settle, then start a fresh INA226 conversion. IO4/IO5 and mux commands are shared with ESP32.
U14E + U19 / U32 | ADJUSTABLE TEST SIGNAL
Applies a small test voltage to one selected experiment row.
Internal ADC/DAC only. Scan with power MOSFETs OFF, other drivers Hi-Z and ESP bypass OPEN. Disable R77 bypass for limited stimulus. A return path is required; occupancy detection is not guaranteed.
U14F + X1 | CLOCK, POWER AND RECOVERY
Starts the AG32 controller and provides local power bypass and debug access.
U14G | SPARE I/O AND ISOLATION CONTROL
Keeps spare controller connections and the last two port-enable signals accessible.
ESP32 TO AG32 | PROGRAMMING AND RECOVERY
Allows loading firmware through ESP32 or an external recovery connection.
ESP TX/RX -> AG UART RX/TX. Boot and reset access are preserved. Recovery requires ESP pins released. Firmware and bootloader sequence are not implemented by this schematic.
J5 / J12 | EXTERNAL EXPANSION
Brings ESP32 and supported AG32 signals to the flat cable and auxiliary header.
GPIO35/36/37 use carrier DNP links. Shared I2C/SPI and boot/strap pins are not unrestricted GPIO. All headers are 3.3 V logic.
J10 / J11 | CARRIER INTERFACE - 2 x 60 CONTACTS
120 contacts: existing services + 22 future-module signals; J11 pins 53 / 54 / 56 remain reserved.
U14B | OWNERSHIP AND GPIO OBSERVATION
Manages the module role and observes additional ESP32 signals.
AG52: release or drive LOW in open-drain; do not drive HIGH. OBS inputs stay Hi-Z. FPGA routing and protocol
bridges still require toolchain validation.
U14C | USB, CAN AND CONTROL LINKS
Exchanges messages with the computer, carrier and optional ESP32.
U14A | SIX-PORT OBSERVATION
Observes the experiment while leaving the direct ESP32 path available.
A0-A5 = ESP side; N_A0-A5 = driver side; PORT_A0-A5 = external side after shunt. Inline FPGA
requires carrier bypass switches OPEN and validated HDL.
MODULE PRESENCE AND PRIORITY
Reports the module presence and selects its shared services.
R109 = 10k pull-up claims services on insertion. R116 pulls MEZZ_PRESENT_N LOW. No
automatic detection of a failed or unpowered fitted module.
SPAGHETTILAB | EXPANSION - AG32 INSTRUMENT MODULE
Functional groups | local wires retained | power shown with symbols | cross-block links use named nets
U14A-U14G are units of ONE physical AG32. All measurements and FPGA features require firmware and prototype validation.
Future-module contacts are intentionally unused by this AG32 module. No new AG32 pins are
assigned.

Board: 4 copper layers, 68 parts (33 on the bottom side), 87 nets, no tracks yet.
